<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Interrupt_Led2.ewp</path>
  </project>
  <batchBuild />
</workspace>
