<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Led_ON_OFF.ewp</path>
  </project>
  <batchBuild />
</workspace>
