<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\GPIO_Led.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\GPIO_Led2\led2.ewp</path>
    </project>
    <batchBuild />
</workspace>
