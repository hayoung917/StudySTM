<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ADC_DMA2_VR_CDS.ewp</path>
  </project>
  <batchBuild />
</workspace>
