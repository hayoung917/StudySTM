<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PWM1_Led.ewp</path>
  </project>
  <batchBuild />
</workspace>
